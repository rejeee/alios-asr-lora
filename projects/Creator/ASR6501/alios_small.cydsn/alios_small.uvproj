# Keil uVision project alios_small.uvproj, settings and files
target alios_small (ARM-GNU)
  device: CY8C4147AZI-S445 Cypress
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x0-0xFFFF) CLOCK(1600000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: alios_small +hex
  BeforeMake: .\Export\prebuild.bat "$L"
  AfterMake: .\Export\postbuild.bat "#L.elf" "$L"
  group Generated_Header
    Generated_Source/PSoC4/: Bootloadable_1.h CyDMA.h CyFlash.h CyLFClk.h CyLib.h RTC.h SPI_1.h SPI_1_BOOT.h SPI_1_PINS.h SPI_1_PVT.h SPI_1_SCBCLK.h SPI_1_SPI_UART.h SPI_1_SPI_UART_PVT.h SPI_1_miso_m.h SPI_1_miso_m_aliases.h SPI_1_mosi_m.h SPI_1_mosi_m_aliases.h SPI_1_sclk_m.h SPI_1_sclk_m_aliases.h SPI_BUSY.h SPI_BUSY_aliases.h SPI_NRESET.h SPI_NRESET_aliases.h UART_1.h UART_1_BOOT.h UART_1_PINS.h UART_1_PVT.h UART_1_RX_WAKEUP_IRQ.h UART_1_SCBCLK.h UART_1_SCB_IRQ.h UART_1_SPI_UART.h UART_1_SPI_UART_PVT.h UART_1_rx_wake.h UART_1_rx_wake_aliases.h UART_1_tx.h UART_1_tx_aliases.h antpow.h antpow_aliases.h cmsis_armcc.h cmsis_compiler.h cmsis_gcc.h core_cm0plus.h core_cm0plus_psoc4.h core_cmFunc.h core_cmInstr.h cyPm.h cy_em_eeprom.h cydevice_trm.h cydevicegnu_trm.inc cydeviceiar_trm.inc cydevicerv_trm.inc cydisabledsheets.h cyfitter.h cyfitter_cfg.h cyfittergnu.inc cyfitteriar.inc cyfitterrv.inc cypins.h cytypes.h dio1.h dio1_aliases.h global_irq.h nss.h nss_aliases.h pin_wakeup.h pin_wakeup_aliases.h project.h wakeup_irq.h
  group Generated_Source
    Generated_Source/PSoC4/: Bootloadable_1.c Cm0plusStart.c CyBootAsmGnu.s CyDMA.c CyFlash.c CyLFClk.c CyLib.c RTC.c SPI_1.c SPI_1_BOOT.c SPI_1_PM.c SPI_1_SCBCLK.c SPI_1_SPI.c SPI_1_SPI_BOOT.c SPI_1_SPI_UART.c SPI_1_miso_m.c SPI_1_miso_m_PM.c SPI_1_mosi_m.c SPI_1_mosi_m_PM.c SPI_1_sclk_m.c SPI_1_sclk_m_PM.c SPI_BUSY.c SPI_BUSY_PM.c SPI_NRESET.c SPI_NRESET_PM.c UART_1.c UART_1_BOOT.c UART_1_PM.c UART_1_RX_WAKEUP_IRQ.c UART_1_SCBCLK.c UART_1_SCB_IRQ.c UART_1_SPI_UART.c UART_1_SPI_UART_INT.c UART_1_UART.c UART_1_UART_BOOT.c UART_1_rx_wake.c UART_1_rx_wake_PM.c UART_1_tx.c UART_1_tx_PM.c antpow.c antpow_PM.c cyPm.c cy_em_eeprom.c cybootloader.c cyfitter_cfg.c cymetadata.c cyutils.c dio1.c dio1_PM.c global_irq.c nss.c nss_PM.c pin_wakeup.c pin_wakeup_PM.c wakeup_irq.c
  group Header
    ../../../../kernel/protocols/lorawan/lora/mac/: LoRaMac.h LoRaMacCrypto.h LoRaMacTest.h
    ../../../../kernel/protocols/lorawan/linkwan/region/: RegionCN470A.h
    ../../../../board/asr6501/inc/: asr_timer.h board-config.h debug.h delay-board.h gpio-board.h gpio.h hw.h hw_conf.h lorawan_port.h rtc-board.h spi-board.h spi.h sx126x-board.h uart-board.h
    ../../../../board/asr6501/: board.h k_config.h
    ./: board_test.h cyapicallbacks.h
    ../../../../include/aos/: cli.h
    ../../../../kernel/protocols/lorawan/: commissioning.h
    ../../../../kernel/protocols/lorawan/lora/system/: delay.h low_power.h timeServer.h timer.h utilities.h
    ../../../../kernel/protocols/lorawan/linkwan/include/: linkwan.h linkwan_ica_at.h
    ../../../../include/hal/: lorawan.h
    ../../../../platform/mcu/cy8c4147/hal/: uart_port.h
  group Source
    ../../../../kernel/protocols/lorawan/lora/mac/: LoRaMac.c LoRaMacConfirmQueue.c LoRaMacCrypto.c
    ../../../../kernel/protocols/lorawan/lora/mac/region/: Region.c RegionCommon.c
    ../../../../kernel/protocols/lorawan/linkwan/region/: RegionCN470A.c
    ../../../../kernel/protocols/lorawan/lora/system/crypto/: aes.c cmac.c
    ../../../../kernel/vcall/aos/: aos_rhino.c
    ../../../../platform/mcu/cy8c4147/runapp/: aos_smallsize.c
    ../../../../board/asr6501/src/: asr_board.c gpio-board.c gpio.c gpio_irq.c spi-board.c
    ../../../../board/asr6501/: board.c
    ../../../../tools/cli/: cli.c dumpsys.c
    ../../../../kernel/protocols/lorawan/lora/system/: delay.c low_power.c utilities.c
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
    ../../../../kernel/rhino/common/: k_fifo.c k_trace.c
    ../../../../kernel/modules/fs/kv/: kvmgr.c
    ../../../../kernel/protocols/lorawan/linkwan/: linkwan.c linkwan_ica_at.c
    ../../../../example/lorawan/loraRun/: loraRun.c
    ../../../../platform/arch/arm/armv6m/gcc/m0/: port_c.c port_s.S
    ../../../../device/lora/asr6501_lrwan/: radio.c
    ../../../../platform/mcu/cy8c4147/aos/: soc_impl.c
    ../../../../device/lora/sx126x/: sx126x.c
    ../../../../platform/mcu/cy8c4147/hal/: uart_port.c
